# Keil uVision project OpenBootloader.uvprojx, settings and files
target N32H473 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: N32H473CE Nationstech
  pack: Nationstech.N32H47x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LION_H473_Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,N32H473,HSE_VALUE=24000000
  c include: ../Core/Inc;../OpenBootloader/App;../OpenBootloader/Target;..\Middlewares\N32\OpenBootloader\Modules\USART;..\Middlewares\N32\OpenBootloader\Modules\FDCAN;..\Middlewares\N32\OpenBootloader\Modules\Mem;..\Middlewares\N32\OpenBootloader\Core;..\Drivers\n32h47x_48x_std_periph_driver\Inc;..\Drivers\CMSIS\core;..\Drivers\CMSIS\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group Application/Core
    ../Core/Src/: main.c n32h47x_48x_it.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/device/startup/: startup_n32h473.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c flash_interface.c iwdg_interface.c ram_interface.c systemmemory_interface.c usart_interface.c fdcan_interface.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Drivers/CMSIS/device/: system_n32h47x_48x.c
  group Drivers/n32h47x_48x_std_periph_driver
    ../Drivers/n32h47x_48x_std_periph_driver/Src/: misc.c n32h47x_48x_adc.c n32h47x_48x_comp.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_dac.c n32h47x_48x_dbg.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_fdcan.c n32h47x_48x_femc.c n32h47x_48x_flash.c n32h47x_48x_fmac.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_iwdg.c n32h47x_48x_lptim.c n32h47x_48x_pga.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_rtc.c n32h47x_48x_sdio.c n32h47x_48x_shrtim.c n32h47x_48x_spi.c n32h47x_48x_tim.c n32h47x_48x_usart.c n32h47x_48x_vrefbuf.c n32h47x_48x_wwdg.c n32h47x_48x_xspi.c
  group Middlewares/OpenBootloader/Core
    ../Middlewares/N32/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/FDCAN
    ../Middlewares/N32/OpenBootloader/Modules/FDCAN/: openbl_fdcan_cmd.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../Middlewares/N32/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../Middlewares/N32/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
software components: CMSIS:CORE 6.1.0
